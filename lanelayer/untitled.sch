v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
L 4 -42.52542257308957 -33.50127816200255 -27.52542257308957 -33.50127816200255 {}
L 4 -127.5254225730896 -53.50127816200255 -106.7441725730896 -53.50127816200255 {}
L 4 -127.5254225730896 -13.50127816200255 -106.7441725730896 -13.50127816200255 {}
L 4 -112.5254225730896 -63.50127816200255 -92.52542257308957 -63.50127816200255 {}
L 4 -112.5254225730896 -3.501278162002549 -92.52542257308957 -3.501278162002549 {}
B 5 -30.02542257308957 -36.00127816200255 -25.02542257308957 -31.00127816200255 {name=Z dir=out}
B 5 -130.0254225730896 -56.00127816200255 -125.0254225730896 -51.00127816200255 {name=A dir=in}
B 5 -130.0254225730896 -16.00127816200255 -125.0254225730896 -11.00127816200255 {name=B dir=in}
A 4 -47.52542257308957 -33.50127816200255 5 180 360 {}
A 4 -152.5254225730896 -33.50127816200255 50 323.130102354156 73.7397952916881 {}
A 4 -97.16827971594671 -15.64413530485969 48.0818286351295 21.80140948635181 62.65738573560834 {}
A 4 -92.21292257308957 -44.75127816200255 41.25118369513777 269.5659493678606 74.60789655596687 {}
T {OR2} -95.23528575897217 -44.08273339271544 0 0 0.3 0.3 {}
